* RC low-pass filter
V1 1 0 1
R1 1 2 1k
C1 2 0 1u

.ac dec 50 10 1e6
