* Example circuit from lecture slides

V1 1 0 10
R1 1 2 1k
R2 2 0 1k
G1 2 0 1 0 1m
